# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\key;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\iwdg;.\APP\wwdg;.\APP\input;.\APP\wkup;.\APP\adc;.\APP\adc_temp;.\APP\dac;.\APP\dma;.\APP\rtc;.\APP\24Cxx;.\APP\iic;.\APP\tftlcd;.\APP\flash;.\APP\spi;.\APP\stm32_flash;.\APP\touch;.\APP\sram;.\Malloc;.\APP\sd_sdio;.\Fatfs\src;.\Fatfs\fatfs_app;.\Font;.\Picture;.\APP\beep;.\APP\lsens;.\APP\ds18b20;.\APP\mpu6050;.\APP\mpu6050\eMPL;.\GUI;.\APP\touch_key;.\GUI_APP;.\ICON;.\APP\hwjs;.\T9INPUT;.\USB\CONFIG;.\USB\STM32_USB-FS-Device_Driver\inc;.\APP\ov7670;.\APP\ov7725;.\APP\can;.\APP\rs232;.\APP\rs485;.\APP\nrf24l01;.\APP\mp3;.\APP\sram;.\APP\dm9000;.\LWIP;.\LWIP\arch;.\LWIP\lwip_app\lwip_comm;.\LWIP\lwip_app\tcp_client_demo;.\LWIP\lwip_app\tcp_server_demo;.\LWIP\lwip_app\udp_demo;.\LWIP\lwip_app\web_server_demo;.\LWIP\lwip-1.4.1\src\include;.\LWIP\lwip-1.4.1\src\include\ipv4;.\LWIP\lwip-1.4.1\src\include\netif;.\APP\beep;.\APP\ws2812
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_can.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/led/: led.c
    ./APP/tftlcd/: tftlcd.c
    ./APP/spi/: spi.c
    ./APP/flash/: flash.c
    ./APP/key/: key.c
    ./APP/sd_sdio/: sd_sdio.c
    ./APP/beep/: beep.c
    ./APP/24Cxx/: 24cxx.c
    ./APP/iic/: iic.c
    ./APP/hwjs/: hwjs.c
    ./APP/mpu6050/: mpu6050.c
    ./APP/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./APP/rtc/: rtc.c
    ./APP/time/: time.c
    ./APP/touch/: ctiic.c gt5663.c touch.c cst716.c
    ./APP/touch_key/: touch_key.c
    ./APP/ds18b20/: ds18b20.c
    ./APP/lsens/: lsens.c
    ./APP/adc_temp/: adc_temp.c
    ./APP/adc/: adc.c
    ./APP/dma/: dma.c
    ./APP/ov7670/: ov7670.c sccb.c
    ./APP/ov7725/: ov7725.c
    ./APP/exti/: exti.c
    ./APP/rs232/: rs232.c
    ./APP/rs485/: rs485.c
    ./APP/can/: can.c
    ./APP/nrf24l01/: nrf24l01.c
    ./APP/sram/: sram.c
    ./APP/ws2812/: ws2812.c
  group Public
    ./Public/: system.c SysTick.c usart.c
  group Malloc
    ./Malloc/: malloc.c
  group Fatfs
    ./Fatfs/src/: diskio.c ff.c
    ./Fatfs/fatfs_app/: fatfs_app.c mycc936.c
  group Font
    ./Font/: font_show.c font_update.c
  group Picture
    ./Picture/: bmp.c gif.c piclib.c tjpgd.c
  group T9INPUT
    ./T9INPUT/: pyinput.c t9input.c
  group USB_core
    ./USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_config
    ./USB/CONFIG/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group GUI
    ./GUI/: button.c edit.c filelistbox.c gui.c listbox.c memo.c progressbar.c scrollbar.c window.c
  group GUI_APP
    ./GUI_APP/: common.c led_app.c rtc_app.c calculator_app.c gyroscope_app.c picture_app.c paint_app.c ebook_app.c notepad_app.c usb_app.c eth_app.c music_app.c camera_app.c com_app.c wireless_app.c phone_app.c qrcode_app.c
